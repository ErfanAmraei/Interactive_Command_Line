# Keil uVision project UART-Interactive-Command-Line.uvproj, settings and files
target Target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UART-Interactive-Command-Line +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER, RTE_DEVICE_STDPERIPH_GPIO, RTE_DEVICE_STDPERIPH_RCC, RTE_DEVICE_STDPERIPH_USART
  c include: .\Headers
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./: startup_stm32f10x_md.s main.c
    ./CMSIS/system_stm32/: system_stm32f10x.c
  group CMSIS
    ./CMSIS/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
    ./Headers/: stm32f10x.h
  group SourceCodes
    ./Source Files/: UART-Command-Line.c
