# Keil uVision project UART_Command_Line.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UART_Command_Line +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD
  c misc: -Wno-unsafe-buffer-usage -Wno-padded
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group system
    ./: startup_stm32f10x_md.s
  group main
    ./: main.c
  group HAL
    ./HAL/HAL_ISR/: UART_isr.c
    ./HAL/HAL-GPIO/src/: hal_gpio_config.c stm32f10x_gpio.c
    ./HAL/HAL-RCC/src/: stm32f10x_rcc.c
    ./HAL/HAL-SYSTEM/src/: hal_common.c misc.c
    ./HAL/HAL-SYSTEM/src/system_stm32/: system_stm32f10x.c
    ./HAL/HAL-UART/src/: hal_usart2_config.c stm32f10x_usart.c
  group Command_line_app
    ./Command_Line_App/memory_utility/: memory_utility.c
    ./Command_Line_App/semaphore/: semaphore.c
    ./Command_Line_App/UART_command_line/: UART-Command-Line.c
